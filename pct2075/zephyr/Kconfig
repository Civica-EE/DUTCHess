## pct2075/zephyr/Kconfig
```kconfig
config PCT2075_DRIVER
	bool "Enable support for the NXP PCT2075 temperature sensor."
	select CONFIG_SENSOR
	
config SENSOR_LOG_LEVEL
	default 4
```
